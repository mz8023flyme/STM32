# Keil uVision project stm32f103ve.uvprojx, settings and files
target SmartCar (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\startup;..\library\inc;..\user;..\driver\led;..\driver\systick;..\driver\usart;..\driver\control;..\driver\motor;..\driver\hcsr04;..\driver\timer;..\driver\NRF24L01;..\driver\SPI;..\driver\adc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group doc
    ../: readme.md
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group library
    ../library/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_adc.c
  group driver
    ../driver/systick/: bsp_systick.c
    ../driver/usart/: bsp_usart.c
    ../driver/motor/: bsp_motor.c
    ../driver/hcsr04/: bsp_hcsr04.c
    ../driver/timer/: bsp_timer.c
    ../driver/NRF24L01/: bsp_NRF24L01.c
    ../driver/SPI/: bsp_spi.c
    ../driver/adc/: bsp_adc.c
  group user
    ../user/: stm32f10x_conf.h stm32f10x_it.c main.c
