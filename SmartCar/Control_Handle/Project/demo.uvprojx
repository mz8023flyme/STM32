# Keil uVision project demo.uvprojx, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Startup;..\Libiary\inc;..\Driver\systick;..\Driver\usart;..\User;..\Driver\NRF24L01;..\Driver\SPI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Startup/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group library
    ../Libiary/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group driver
    ../Driver/systick/: bsp_systick.c
    ../Driver/usart/: bsp_usart.c
    ../Driver/NRF24L01/: bsp_NRF24L01.c
    ../Driver/SPI/: bsp_spi.c
  group user
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
