# Keil uVision project stm32f103ve.uvprojx, settings and files
target stm32f103ve (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\startup;..\library\inc;..\user;..\driver\led;..\driver\systick;..\driver\usart;..\driver\lcd;..\driver\SPI;..\driver\font;..\driver\Tetris;..\driver\BasicTime;..\driver\adc;..\driver\KEY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group doc
    ../: readme.md
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group library
    ../library/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_adc.c
  group driver
    ../driver/systick/: bsp_systick.c
    ../driver/usart/: bsp_usart.c
    ../driver/SPI/: bsp_spi.c
    ../driver/font/: fonts.c
    ../driver/lcd/: bsp_lcd.c
    ../driver/Tetris/: bsp_tetris.c
    ../driver/BasicTime/: bsp_basictime.c
    ../driver/adc/: bsp_adc.c
    ../driver/KEY/: bsp_key.c
  group user
    ../user/: stm32f10x_conf.h stm32f10x_it.c main.c
